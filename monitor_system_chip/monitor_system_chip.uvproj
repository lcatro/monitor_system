# Keil uVision project monitor_system_chip.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: monitor_system_chip +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: monitor_system_chip.c monitor_system_chip.h monitor_system_code_trance.c monitor_system_code_trance.h monitor_system_trance_data.h monitor_system_code_password.h
  group Device
    ./: device_lcd_1602.c device_lcd_1602.h device_52_trance.c device_52_trance.h device_io_interrupt.c device_io_interrupt.h device_eeprom.c device_eeprom.h device_key.c device_key.h device_delay.c device_delay.h
